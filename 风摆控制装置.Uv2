### uVision2 Project, (C) Keil Software
### Do not modify !

Target (Target 1), 0x0000 // Tools: 'MCS-51'

Group (USER)
Group (DISPLAY)
Group (BUTTON)
Group (MOTOR)
Group (MAIN)
Group (ANGLE)
Group (RTOS)
Group (GUI)

File 1,1,<.\USER\USER.C><USER.C> 0x0 
File 1,1,<.\USER\stc15_pwm.c><stc15_pwm.c> 0x0 
File 1,1,<.\USER\timer.c><timer.c> 0x0 
File 1,1,<.\USER\USART1.C><USART1.C> 0x0 
File 1,1,<.\USER\GPIO.c><GPIO.c> 0x0 
File 1,1,<.\USER\delay.c><delay.c> 0x0 
File 1,1,<.\USER\ADC.c><ADC.c> 0x0 
File 2,1,<.\DISPLAY\DISPLAY.C><DISPLAY.C> 0x0 
File 2,1,<.\DISPLAY\DataScope_DP.c><DataScope_DP.c> 0x0 
File 3,1,<.\BUTTON\BUTTON.C><BUTTON.C> 0x0 
File 4,1,<.\MOTOR\MOTOR.C><MOTOR.C> 0x0 
File 5,1,<.\MAIN\MAIN.C><MAIN.C> 0x0 
File 6,1,<.\ANGLE\ANGLE.C><ANGLE.C> 0x0 
File 7,1,<.\RTOS\OS.c><OS.c> 0x0 
File 7,1,<.\RTOS\OS_TASK.C><OS_TASK.C> 0x0 
File 8,1,<.\GUI\font5_7.c><font5_7.c> 0x0 
File 8,1,<.\GUI\FONT8_8.C><FONT8_8.C> 0x0 
File 8,1,<.\GUI\GUI_BASIC.C><GUI_BASIC.C> 0x0 
File 8,1,<.\GUI\GUI_StockC.C><GUI_StockC.C> 0x0 
File 8,1,<.\GUI\loadbit.c><loadbit.c> 0x0 
File 8,1,<.\GUI\menu.c><menu.c> 0x0 
File 8,1,<.\GUI\windows.c><windows.c> 0x0 


Options 1,0,0  // Target 'Target 1'
 Device (STC15W4K32S4)
 Vendor (STC)
 Cpu (IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2)
 FlashUt ()
 StupF ("LIB\STARTUP.A51" ("Standard 8051 Startup Code"))
 FlashDR ()
 DevID ()
 Rgf (STC15F2K60S2.H)
 Mem ()
 C ()
 A ()
 RL ()
 OH ()
 DBC_IFX ()
 DBC_CMS ()
 DBC_AMS ()
 DBC_LMS ()
 UseEnv=0
 EnvBin ()
 EnvInc ()
 EnvLib ()
 EnvReg (ÿSTC\)
 OrgReg (ÿSTC\)
 TgStat=16
 OutDir (.\)
 OutName (·ç°Ú¿ØÖÆ×°ÖÃ)
 GenApp=1
 GenLib=0
 GenHex=1
 Debug=1
 Browse=1
 LstDir (.\)
 HexSel=0
 MG32K=0
 TGMORE=0
 RunUsr 0 0 <>
 RunUsr 1 0 <>
 BrunUsr 0 0 <>
 BrunUsr 1 0 <>
 SVCSID <>
 MODEL5=2
 RTOS5=0
 ROMSZ5=2
 DHOLD5=0
 XHOLD5=0
 T51FL=624
 XT51FL=0
 CBANKS5=0
 XBANKS5=0
 RCB51 { 0,0,0,0,0,255,255,0,0 }
 RXB51 { 0,0,0,0,0,0,0,0,0 }
 OCM51 { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCR51 { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IRO51 { 1,0,0,0,0,249,239,0,0 }
 IRA51 { 0,0,0,0,0,0,1,0,0 }
 XRA51 { 0,0,0,0,0,0,15,0,0 }
 XRA512 { 0,0,0,0,0,0,0,0,0 }
 IROM512 { 0,0,0,0,0,0,0,0,0 }
 C51FL=21630224
 C51VA=0
 C51MSC ()
 C51DEF ()
 C51UDF ()
 INCC5 ()
 AX51FL=4
 AX51MSC ()
 AX51SET ()
 AX51RST ()
 INCA5 ()
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=1
 AlwaysBuild=0
 GenAsm=0
 AsmAsm=0
 PublicsOnly=0
 StopCode=3
 CustArgs ()
 LibMods ()
 BankNo=65535
 LX51FL=292
 LX51OVL ()
 LX51MSC ()
 LX51DWN ()
 LX51LFI ()
 LX51ASN ()
 LX51RES ()
 LX51CCL ()
 LX51UCL ()
 LX51CSC ()
 LX51UCS ()
 LX51COB ()
 LX51XDB ()
 LX51PDB ()
 LX51BIB ()
 LX51DAB ()
 LX51IDB ()
 LX51PRC ()
 LX51STK ()
 LX51COS ()
 LX51XDS ()
 LX51BIS ()
 LX51DAS ()
 LX51IDS ()
  OPTDL (S8051.DLL)()(DP51.DLL)(-pDP8051)(S8051.DLL)()(TP51.DLL)(-p51)
  OPTDBG 49149,8,()()()()()()()()()() (BIN\STCMON51.DLL)()()()
 FLASH1 { 1,0,0,0,0,0,0,0,255,255,255,255,0,0,0,0,0,0,0,0 }
 FLASH2 ()
 FLASH3 ("" ())
 FLASH4 ()
EndOpt

