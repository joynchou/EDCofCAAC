# Keil uVision project 风摆控制装置.uvproj, settings and files
target STC15W (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 风摆控制装置 +hex
  c flags: Optimize=8 SizeSpeed=1
  group USER
    ./USER/: USER.C Readme.txt UI.C ADC.c delay.c GPIO.c stc15_pwm.c timer.c USART1.C
  group RTOS
    ./RTOS/: OS.c OS_TASK.C Readme.txt
  group MOTOR
    ./MOTOR/: MOTOR.C Readme.txt
  group BUTTON
    ./BUTTON/: BUTTON.C Readme.txt
  group DISPLAY
    ./DISPLAY/: Readme.txt DataScope_DP.c DISPLAY.C
  group ANGLE
    ./ANGLE/: ANGLE.C Readme.txt
  group MAIN
    ./MAIN/: MAIN.C Readme.txt
  group GUI
    ./GUI/: GUI_BASIC.C menu.c windows.c FONT8_8.C GUI_StockC.C font5_7.c loadbit.c Readme.txt
